# Keil uVision project L50T-MAU.uvproj, settings and files
target L50T-MAU (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: L50T-MAU
  AfterMake: C:\worksoft\keil\ARM\ARMCC\bin\fromelf.exe --bin -o ./Output/L50T-MAU.bin ./Output/L50T-MAU.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,
  c misc: --c99
  c include: ..\CMSIS;..\USER;..\FWlib\src;..\FWlib\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ./: startup_stm32f10x_md.s
  group USER
    ../USER/: function.c main.c stm32f10x_it.c SysTick.c candata.c TIMIRQHandler.c gpioint.c RCCANDNVIC.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
